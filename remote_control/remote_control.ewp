# IAR project remote_control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C6 ST STM32F030C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.PreInclude: Libraries\STM32F0xx_StdPeriph_Driver\stm32f0xx_conf.h
  ICCARM.CCIncludePath2: ; src\; inc\; Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\STM32F0xx_StdPeriph_Driver\src; Libraries\CMSIS\Device\ST\STM32F0xx\Include; Libraries\CMSIS\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.5\arm\CMSIS\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.3\arm\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: remote_control.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
    Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s
  group _lib
    Libraries/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_iwdg.c stm32f0xx_rcc.c
    Libraries/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_iwdg.h stm32f0xx_rcc.h
  group inc
    inc/: adc_vbat.h enc_but.h gpio_macros.h hal.h modbus.h spi.h usart.h
  group src
    src/: adc_vbat.c enc_but.c hal.c modbus.c spi.c usart.c
